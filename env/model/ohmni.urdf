Commit message: complete ohmni model

File: env/model/ohmni.urdf (robot description, URDF)
Before this commit: robot ohmni, 7 links, 6 joints
Joints:
- joint neck_joint: axis 0.0 1 0.0 -> 0 1 0
